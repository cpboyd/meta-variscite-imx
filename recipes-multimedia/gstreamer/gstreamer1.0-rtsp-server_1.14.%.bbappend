# Disable introspection to fix [GstRtsp-1.0.gir] Error
EXTRA_OECONF_append = " --disable-introspection"
