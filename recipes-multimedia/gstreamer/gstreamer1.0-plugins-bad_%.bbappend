FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

SRC_URI += " \
    file://0002-opencv-Fix-build-with-opencv-3.4.5.patch \
"
